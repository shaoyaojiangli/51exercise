# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: project +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\AT24C02;.\Delay;.\DS18B20;.\I2C;.\key;.\LCD1602;.\OneWhile;.\time
  group Source Group 1
    ./: main.c
  group Delay
    ./Delay/: Delay.c Delay.h
  group DS18B20
    ./DS18B20/: DS18B20.c DS18B20.h
  group AT24C02
    ./AT24C02/: AT24C02.c AT24C02.h
  group I2C
    ./I2C/: I2C.c I2C.h
  group key
    ./key/: key.c key.h
  group LCD1602
    ./LCD1602/: LCD1602.c LCD1602.h
  group OneWire
    ./OneWhile/: OneWhile.c OneWhile.h
  group time
    ./time/: time0.c time0.h
