# Keil uVision project clock.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: clock +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\LCD1602;.\DS1302;.\Delay;.\key;.\time
  group Source Group 1
    ./: main.c
  group LCD1602
    ./LCD1602/: LCD1602.c LCD1602.h
  group DS1302
    ./DS1302/: DS1302.c DS1302.h
  group Delay
    ./Delay/: Delay.c Delay.h
  group Time
    ./time/: time0.c time0.h
  group Key
    ./key/: key.c key.h
