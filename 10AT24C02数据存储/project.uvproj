# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: project +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Delay;.\key;.\LCD1602;.\I2C;.\AT24C02
  group Source Group 1
    ./: main.c
  group LCD1602
    ./LCD1602/: LCD1602.c LCD1602.h
  group key
    ./key/: key.c key.h
  group Delay
    ./Delay/: Delay.c Delay.h
  group AT24C02
    ./AT24C02/: AT24C02.c AT24C02.h
  group I2C
    ./I2C/: I2C.c I2C.h
