# Keil uVision project music.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: music +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Delay;.\time
  group Source Group 1
    ./: main.c
  group Time
    ./time/: timer0.c timer0.h
  group Delay
    ./Delay/: Delay.c Delay.h
