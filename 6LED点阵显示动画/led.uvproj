# Keil uVision project led.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: led +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Delay;.\MatrixLED
  group Source Group 1
    ./: main.c
  group Delay
    ./Delay/: Delay.c Delay.h
  group MatrixLED
    ./MatrixLED/: MatrixLED.c MatrixLED.h
