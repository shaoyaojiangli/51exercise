# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: project +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Delay;.\LCD1602;.\DS18B20;.\OneWhile
  group Source Group 1
    ./: main.c
  group LCD602
    ./LCD1602/: LCD1602.c LCD1602.h
  group Delay
    ./Delay/: Delay.c Delay.h
  group OneWhlie
    ./OneWhile/: OneWhile.c OneWhile.h
  group DS18B20
    ./DS18B20/: DS18B20.c DS18B20.h
