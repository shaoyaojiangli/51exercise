# Keil uVision project clock.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: clock +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Delay;.\LCD1602;.\time
  group main
    ./: main.c
  group Delay
    ./Delay/: Delay.c Delay.h
  group LCD1602
    ./LCD1602/: LCD1602.c LCD1602.h
  group timer0
    ./time/: time0.c time0.h
