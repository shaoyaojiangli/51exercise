# Keil uVision project chuankou.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: chuankou +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Delay;.\UART
  group main
    ./: main.c
  group Delay
    ./Delay/: Delay.c Delay.h
  group Uart
    ./UART/: UART.c UART.h
