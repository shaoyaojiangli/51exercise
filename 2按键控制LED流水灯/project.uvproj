# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: project +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Delay
  group main
    ./: main.c
  group time
    ./time/: time0.c time0.h
  group key
    ./key/: key.c key.h
  group delay
    ./Delay/: Delay.c Delay.h
