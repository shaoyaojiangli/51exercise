# Keil uVision project LCD.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: LCD +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\LCD1602;.\Delay
  group Source Group 1
    ./: main.c
  group LCD
    ./LCD1602/: LCD1602.c LCD1602.h
  group Delay
    ./Delay/: Delay.c Delay.h
