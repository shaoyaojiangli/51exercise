# Keil uVision project beep.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: beep +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Delay;.\key;.\nixie;.\Buzzer
  group Source Group 1
    ./: main.c
  group Delay
    ./Delay/: Delay.c Delay.h
  group Key
    ./key/: key.c key.h
  group Nixie
    ./nixie/: Nixie.c Nixie.h
  group Buzzer
    ./Buzzer/: Buzzer.c Buzzer.h
